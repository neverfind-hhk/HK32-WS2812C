# Keil uVision project HK32F030M.uvprojx, settings and files
target HK32F030M (ARM-ADS)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F030M
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ./CMSIS/Startup/: startup_hk32f030m.s
