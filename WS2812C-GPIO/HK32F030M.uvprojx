# Keil uVision project HK32F030M.uvprojx, settings and files
target HK32F030M (6220000::V6.22::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F030M
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HK32F030MF4P6
  c include: .\Driver\inc;.\CMSIS\Include;.\User
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ./User/: hk32f030m_conf.h hk32f030m_it.c hk32f030m_it.h main.c main.h ws2812.c ws2812.h gpio.c gpio.h
  group Libraries
    ./Driver/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_dbgmcu.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
    ./Driver/inc/: hk32f030m_adc.h hk32f030m_awu.h hk32f030m_beep.h hk32f030m_conf.h hk32f030m_conf_Template.h hk32f030m_crc.h hk32f030m_dbgmcu.h hk32f030m_def.h hk32f030m_exti.h hk32f030m_flash.h hk32f030m_gpio.h hk32f030m_i2c.h hk32f030m_iwdg.h hk32f030m_misc.h hk32f030m_pwr.h hk32f030m_rcc.h hk32f030m_spi.h hk32f030m_syscfg.h hk32f030m_tim.h hk32f030m_usart.h hk32f030m_wwdg.h
  group CMSIS
    ./CMSIS/Source/: system_hk32f030m.c
    ./CMSIS/Include/: system_hk32f030m.h hk32f030m.h hk32f030m_2k.h hk32f030m_common.h core_cm0.h
    ./CMSIS/Startup/: startup_hk32f030m.s
